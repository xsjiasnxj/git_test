# Keil uVision project project.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_STDPERIPH_DRIVER,STM32F446xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT,__FPU_USED
  c misc: --locale=english  --diag_suppress=1
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM;.\GLOBAL;../HARDWARE/EXTI;../HARDWARE/OLED;../HARDWARE/KEY;../HARDWARE/PWM;../HARDWARE/DMA;../HARDWARE/TIMER;../HARDWARE/BUZZER;../HARDWARE/spi;../HARDWARE/AD7606;../HARDWARE/ADC;../HARDWARE/GPIO;../SOFTWARE/PLL;../SOFTWARE/SPWM;../SOFTWARE/DISP;../SOFTWARE/PID;../SOFTWARE/timer_handler;../SOFTWARE/VOFA;../SOFTWARE/MENU;..\DSP\Include;..\DSP
  asm include: ../HARDWARE/OLED;../HARDWARE/AD7606;../HARDWARE/KEY;../HARDWARE/spi;../HARDWARE/PWM;../HARDWARE/DMA;../HARDWARE/TIMER;../HARDWARE/ADC;../HARDWARE/EXTI;../HARDWARE/BUZZER;../HARDWARE/GPIO;../SOFTWARE/timer_handler;../SOFTWARE/DISP;../SOFTWARE/MENU;../SOFTWARE/VOFA;../SOFTWARE/PLL;../SOFTWARE/PID;../SOFTWARE/SPWM;../SOFTWARE/filterDemo;../HARDWARE/TIMER/timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c stm32f4xx_it.c main.c main.h
    ./GLOBAL/: global.c global.h
  group SOFTWARE
    ../SOFTWARE/DISP/: disp.c disp.h
    ../SOFTWARE/PID/: pid.c pid.h
    ../SOFTWARE/PLL/: pll.c pll.h sogi.c sogi.h transform.c transform.h
    ../SOFTWARE/SPWM/: spwm.c spwm.h
    ../SOFTWARE/timer_handler/: timer_handler.c timer_handler.h
    ../SOFTWARE/VOFA/: Vofa.c Vofa.h
    ../SOFTWARE/MENU/: MENU.h MENU.c
  group HARDWARE
    ../HARDWARE/AD7606/: AD7606.c AD7606.h
    ../HARDWARE/ADC/: adc.c adc.h
    ../HARDWARE/BUZZER/: buzzer.c buzzer.h
    ../HARDWARE/DMA/: dma.c dma.h
    ../HARDWARE/EXTI/: exti.h exti.c
    ../HARDWARE/GPIO/: gpio.c gpio.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/PWM/: pwm.c pwm.h
    ../HARDWARE/spi/: spi.c spi.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_dac.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
